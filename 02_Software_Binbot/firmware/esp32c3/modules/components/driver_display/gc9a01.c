#include "esp_lcd_panel_io.h"
#include "freertos/FreeRTOS.h"
#include "freertos/task.h"

#include "esp_err.h"

typedef struct {
    uint8_t command;
    uint8_t data[16];
    uint8_t length;
} gc9a01a_command_t;

esp_err_t gc9a01a_register_init(esp_lcd_panel_io_handle_t io)
{
    static const gc9a01a_command_t commands[] = {
        {0xEF, {0}, 0},
        {0xEB, {0x14}, 1},
        {0xFE, {0}, 0},
        {0xEF, {0}, 0},
        {0xEB, {0x14}, 1},
        {0x84, {0x40}, 1},
        {0x85, {0xFF}, 1},
        {0x86, {0xFF}, 1},
        {0x87, {0xFF}, 1},
        {0x88, {0x0A}, 1},
        {0x89, {0x21}, 1},
        {0x8A, {0x00}, 1},
        {0x8B, {0x80}, 1},
        {0x8C, {0x01}, 1},
        {0x8D, {0x01}, 1},
        {0x8E, {0xFF}, 1},
        {0x8F, {0xFF}, 1},
        {0xB6, {0x00, 0x20}, 2},
        {0x90, {0x08, 0x08, 0x08, 0x08}, 4},
        {0xBD, {0x06}, 1},
        {0xBC, {0x00}, 1},
        {0xFF, {0x60, 0x01, 0x04}, 3},
        {0xC3, {0x13}, 1},
        {0xC4, {0x13}, 1},
        {0xC9, {0x22}, 1},
        {0xBE, {0x11}, 1},
        {0xE1, {0x10, 0x0E}, 2},
        {0xDF, {0x21, 0x0C, 0x02}, 3},
        {0xF0, {0x45, 0x09, 0x08, 0x08, 0x26, 0x2A}, 6},
        {0xF1, {0x43, 0x70, 0x72, 0x36, 0x37, 0x6F}, 6},
        {0xF2, {0x45, 0x09, 0x08, 0x08, 0x26, 0x2A}, 6},
        {0xF3, {0x43, 0x70, 0x72, 0x36, 0x37, 0x6F}, 6},
        {0xED, {0x1B, 0x0B}, 2},
        {0xAE, {0x77}, 1},
        {0xCD, {0x63}, 1},
        {0x70, {0x07, 0x07, 0x04, 0x0E, 0x0F, 0x09, 0x07, 0x08, 0x03}, 9},
        {0xE8, {0x34}, 1},
        {0x60, {0x38, 0x0B, 0x6D, 0x6D, 0x39, 0xF0, 0x6D, 0x6D}, 8},
        {0x61, {0x38, 0xF4, 0x6D, 0x6D, 0x38, 0xF7, 0x6D, 0x6D}, 8},
        {0x62, {0x18, 0x0D, 0x71, 0xED, 0x70, 0x70,
                0x18, 0x0F, 0x71, 0xEF, 0x70, 0x70}, 12},
        {0x63, {0x18, 0x11, 0x71, 0xF1, 0x70, 0x70,
                0x18, 0x13, 0x71, 0xF3, 0x70, 0x70}, 12},
        {0x64, {0x28, 0x29, 0xF1, 0x01, 0xF1, 0x00, 0x07}, 7},
        {0x66, {0x3C, 0x00, 0xCD, 0x67, 0x45, 0x45, 0x10, 0x00, 0x00, 0x00}, 10},
        {0x67, {0x00, 0x3C, 0x00, 0x00, 0x00, 0x01,
                0x54, 0x10, 0x32, 0x98}, 10},
        {0x74, {0x10, 0x85, 0x80, 0x00, 0x00, 0x4E, 0x00}, 7},
        {0x98, {0x3E, 0x07}, 2},
        {0x99, {0x3E, 0x07}, 2},
    };
    // This panel uses BGR color order for incoming RGB565 data.
    static const uint8_t madctl[] = {0x08};
    static const uint8_t pixfmt[] = {0x05};

    esp_err_t error = ESP_OK;
    for (size_t index = 0; index < sizeof(commands) / sizeof(commands[0]); ++index) {
        error = esp_lcd_panel_io_tx_param(io, commands[index].command,
                                          commands[index].data,
                                          commands[index].length);
        if (error != ESP_OK) {
            return error;
        }
    }

    error = esp_lcd_panel_io_tx_param(io, 0x36, madctl, sizeof(madctl));
    if (error != ESP_OK) {
        return error;
    }
    error = esp_lcd_panel_io_tx_param(io, 0x3A, pixfmt, sizeof(pixfmt));
    if (error != ESP_OK) {
        return error;
    }
    error = esp_lcd_panel_io_tx_param(io, 0x35, NULL, 0);
    if (error != ESP_OK) {
        return error;
    }
    // This panel is electrically inverted: enable display inversion so that
    // RGB565 black and white appear with their expected polarity.
    error = esp_lcd_panel_io_tx_param(io, 0x21, NULL, 0);
    if (error != ESP_OK) {
        return error;
    }
    error = esp_lcd_panel_io_tx_param(io, 0x11, NULL, 0);
    if (error != ESP_OK) {
        return error;
    }
    vTaskDelay(pdMS_TO_TICKS(120));
    error = esp_lcd_panel_io_tx_param(io, 0x29, NULL, 0);
    if (error != ESP_OK) {
        return error;
    }
    vTaskDelay(pdMS_TO_TICKS(20));
    return ESP_OK;
}
