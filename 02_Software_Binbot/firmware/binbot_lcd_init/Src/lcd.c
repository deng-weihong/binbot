/**
  ******************************************************************************
  * @file    lcd.c
  * @brief   ST7701 and NV3052CGRB LCD initialization over 3-wire SPI.
  ******************************************************************************
  */

#include "lcd.h"

typedef struct
{
  uint8_t cmd;
  uint8_t data[16];
  uint8_t data_bytes;
} LCD_InitCmdTypeDef;

#define LCD_INIT_END_MARKER       0xFFU
#define LCD_INIT_DELAY_MARKER     0xFEU

#define LCD_CS_LOW()              HAL_GPIO_WritePin(LCD_SPI_CS_GPIO_PORT, LCD_SPI_CS_PIN, GPIO_PIN_RESET)
#define LCD_CS_HIGH()             HAL_GPIO_WritePin(LCD_SPI_CS_GPIO_PORT, LCD_SPI_CS_PIN, GPIO_PIN_SET)
#define LCD_SCL_LOW()             HAL_GPIO_WritePin(LCD_SPI_SCL_GPIO_PORT, LCD_SPI_SCL_PIN, GPIO_PIN_RESET)
#define LCD_SCL_HIGH()            HAL_GPIO_WritePin(LCD_SPI_SCL_GPIO_PORT, LCD_SPI_SCL_PIN, GPIO_PIN_SET)
#define LCD_SDA_LOW()             HAL_GPIO_WritePin(LCD_SPI_SDA_GPIO_PORT, LCD_SPI_SDA_PIN, GPIO_PIN_RESET)
#define LCD_SDA_HIGH()            HAL_GPIO_WritePin(LCD_SPI_SDA_GPIO_PORT, LCD_SPI_SDA_PIN, GPIO_PIN_SET)

static void LCD_GPIO_Init(void);
static void LCD_Reset(void);
static void LCD_WriteCommand(uint8_t cmd);
static void LCD_WriteData(uint8_t data);
static void LCD_WriteInitTable(const LCD_InitCmdTypeDef *table);
static void LCD_Write9Bits(uint16_t value);
static void LCD_DelayUs(uint32_t us);

static const LCD_InitCmdTypeDef ST7701_InitTable[] =
{
  {0x11, {0x00}, 0},
  {0x00, {120, 0}, LCD_INIT_DELAY_MARKER},
  {0xFF, {0x77, 0x01, 0x00, 0x00, 0x10}, 5},
  {0xC0, {0x3B, 0x00}, 2},
  {0xC1, {0x0D, 0x02}, 2},
  {0xC2, {0x31, 0x05}, 2},
  {0xCD, {0x08}, 1},
  {0xB0, {0x00, 0x11, 0x18, 0x0E, 0x11, 0x06, 0x07, 0x08, 0x07, 0x22, 0x04, 0x12, 0x0F, 0xAA, 0x31, 0x18}, 16},
  {0xB1, {0x00, 0x11, 0x19, 0x0E, 0x12, 0x07, 0x08, 0x08, 0x08, 0x22, 0x04, 0x11, 0x11, 0xA9, 0x32, 0x18}, 16},
  {0xFF, {0x77, 0x01, 0x00, 0x00, 0x11}, 5},
  {0xB0, {0x60}, 1},
  {0xB1, {0x32}, 1},
  {0xB2, {0x07}, 1},
  {0xB3, {0x80}, 1},
  {0xB5, {0x49}, 1},
  {0xB7, {0x85}, 1},
  {0xB8, {0x21}, 1},
  {0xC1, {0x78}, 1},
  {0xC2, {0x78}, 1},
  {0xE0, {0x00, 0x1B, 0x02}, 3},
  {0xE1, {0x08, 0xA0, 0x00, 0x00, 0x07, 0xA0, 0x00, 0x00, 0x00, 0x44, 0x44}, 11},
  {0xE2, {0x11, 0x11, 0x44, 0x44, 0xED, 0xA0, 0x00, 0x00, 0xEC, 0xA0, 0x00, 0x00}, 12},
  {0xE3, {0x00, 0x00, 0x11, 0x11}, 4},
  {0xE4, {0x44, 0x44}, 2},
  {0xE5, {0x0A, 0xE9, 0xD8, 0xA0, 0x0C, 0xEB, 0xD8, 0xA0, 0x0E, 0xED, 0xD8, 0xA0, 0x10, 0xEF, 0xD8, 0xA0}, 16},
  {0xE6, {0x00, 0x00, 0x11, 0x11}, 4},
  {0xE7, {0x44, 0x44}, 2},
  {0xE8, {0x09, 0xE8, 0xD8, 0xA0, 0x0B, 0xEA, 0xD8, 0xA0, 0x0D, 0xEC, 0xD8, 0xA0, 0x0F, 0xEE, 0xD8, 0xA0}, 16},
  {0xEB, {0x02, 0x00, 0xE4, 0xE4, 0x88, 0x00, 0x40}, 7},
  {0xEC, {0x3C, 0x00}, 2},
  {0xED, {0xAB, 0x89, 0x76, 0x54, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x20, 0x45, 0x67, 0x98, 0xBA}, 16},
  {0xFF, {0x77, 0x01, 0x00, 0x00, 0x13}, 5},
  {0xE5, {0xE4}, 1},
  {0xFF, {0x77, 0x01, 0x00, 0x00, 0x00}, 5},
  {0x3A, {0x60}, 1},
  {0x11, {0x00}, 0},
  {0x00, {120, 0}, LCD_INIT_DELAY_MARKER},
  {0x29, {0x00}, 0},
  {0x21, {0x00}, 0},
  {0xFF, {0x77, 0x01, 0x00, 0x00, 0x10}, 5},
  {0xC7, {0x00}, 1},
  {0xFF, {0x77, 0x01, 0x00, 0x00, 0x00}, 5},
  {0x36, {0x00}, 1},
  {0x00, {0x00}, LCD_INIT_END_MARKER},
};

static const LCD_InitCmdTypeDef NV3052CGRB_InitTable[] =
{
  /* 720x720 BOE 3.95-inch 6G (B3 QV040YNQ-N80) */
  {0xFF, {0x30}, 1}, {0xFF, {0x52}, 1}, {0xFF, {0x01}, 1}, {0xE3, {0x00}, 1},
  {0x0A, {0x01}, 1}, {0x23, {0xA0}, 1}, {0x24, {0x0F}, 1}, {0x25, {0x14}, 1},
  {0x26, {0x2E}, 1}, {0x27, {0x2E}, 1}, {0x29, {0x02}, 1}, {0x2A, {0xCF}, 1},
  {0x32, {0x34}, 1}, {0x38, {0x9C}, 1}, {0x39, {0xA7}, 1}, {0x3A, {0x4F}, 1},
  {0x3B, {0x94}, 1}, {0x40, {0x07}, 1}, {0x42, {0x6D}, 1}, {0x43, {0x83}, 1},
  {0x81, {0x00}, 1}, {0x91, {0x57}, 1}, {0x92, {0x57}, 1}, {0xA0, {0x52}, 1},
  {0xA1, {0x50}, 1}, {0xA4, {0x9C}, 1}, {0xA7, {0x02}, 1}, {0xA8, {0x02}, 1},
  {0xA9, {0x02}, 1}, {0xAA, {0xA8}, 1}, {0xAB, {0x28}, 1}, {0xAE, {0xD2}, 1},
  {0xAF, {0x02}, 1}, {0xB0, {0xD2}, 1}, {0xB2, {0x26}, 1}, {0xB3, {0x26}, 1},
  {0xFF, {0x30}, 1}, {0xFF, {0x52}, 1}, {0xFF, {0x02}, 1}, {0xB0, {0x02}, 1},
  {0xB1, {0x31}, 1}, {0xB2, {0x24}, 1}, {0xB3, {0x30}, 1}, {0xB4, {0x38}, 1},
  {0xB5, {0x3E}, 1}, {0xB6, {0x26}, 1}, {0xB7, {0x3E}, 1}, {0xB8, {0x0A}, 1},
  {0xB9, {0x00}, 1}, {0xBA, {0x11}, 1}, {0xBB, {0x11}, 1}, {0xBC, {0x13}, 1},
  {0xBD, {0x14}, 1}, {0xBE, {0x18}, 1}, {0xBF, {0x11}, 1}, {0xC0, {0x16}, 1},
  {0xC1, {0x00}, 1}, {0xD0, {0x05}, 1}, {0xD1, {0x30}, 1}, {0xD2, {0x25}, 1},
  {0xD3, {0x35}, 1}, {0xD4, {0x34}, 1}, {0xD5, {0x3B}, 1}, {0xD6, {0x26}, 1},
  {0xD7, {0x3D}, 1}, {0xD8, {0x0A}, 1}, {0xD9, {0x00}, 1}, {0xDA, {0x12}, 1},
  {0xDB, {0x10}, 1}, {0xDC, {0x12}, 1}, {0xDD, {0x14}, 1}, {0xDE, {0x18}, 1},
  {0xDF, {0x11}, 1}, {0xE0, {0x15}, 1}, {0xE1, {0x00}, 1},
  {0xFF, {0x30}, 1}, {0xFF, {0x52}, 1}, {0xFF, {0x03}, 1}, {0x00, {0x00}, 1},
  {0x01, {0x00}, 1}, {0x02, {0x00}, 1}, {0x03, {0x00}, 1}, {0x08, {0x0D}, 1},
  {0x09, {0x0E}, 1}, {0x0A, {0x0F}, 1}, {0x0B, {0x10}, 1}, {0x20, {0x00}, 1},
  {0x21, {0x00}, 1}, {0x22, {0x00}, 1}, {0x23, {0x00}, 1}, {0x28, {0x22}, 1},
  {0x2A, {0xE9}, 1}, {0x2B, {0xE9}, 1}, {0x30, {0x00}, 1}, {0x31, {0x00}, 1},
  {0x32, {0x00}, 1}, {0x33, {0x00}, 1}, {0x34, {0x01}, 1}, {0x35, {0x00}, 1},
  {0x36, {0x00}, 1}, {0x37, {0x03}, 1}, {0x40, {0x0A}, 1}, {0x41, {0x0B}, 1},
  {0x42, {0x0C}, 1}, {0x43, {0x0D}, 1}, {0x44, {0x22}, 1}, {0x45, {0xE4}, 1},
  {0x46, {0xE5}, 1}, {0x47, {0x22}, 1}, {0x48, {0xE6}, 1}, {0x49, {0xE7}, 1},
  {0x50, {0x0E}, 1}, {0x51, {0x0F}, 1}, {0x52, {0x10}, 1}, {0x53, {0x11}, 1},
  {0x54, {0x22}, 1}, {0x55, {0xE8}, 1}, {0x56, {0xE9}, 1}, {0x57, {0x22}, 1},
  {0x58, {0xEA}, 1}, {0x59, {0xEB}, 1}, {0x60, {0x05}, 1}, {0x61, {0x05}, 1},
  {0x65, {0x0A}, 1}, {0x66, {0x0A}, 1}, {0x80, {0x05}, 1}, {0x81, {0x00}, 1},
  {0x82, {0x02}, 1}, {0x83, {0x04}, 1}, {0x84, {0x00}, 1}, {0x85, {0x00}, 1},
  {0x86, {0x1F}, 1}, {0x87, {0x1F}, 1}, {0x88, {0x0A}, 1}, {0x89, {0x0C}, 1},
  {0x8A, {0x0E}, 1}, {0x8B, {0x10}, 1}, {0x96, {0x05}, 1}, {0x97, {0x00}, 1},
  {0x98, {0x01}, 1}, {0x99, {0x03}, 1}, {0x9A, {0x00}, 1}, {0x9B, {0x00}, 1},
  {0x9C, {0x1F}, 1}, {0x9D, {0x1F}, 1}, {0x9E, {0x09}, 1}, {0x9F, {0x0B}, 1},
  {0xA0, {0x0D}, 1}, {0xA1, {0x0F}, 1},
  {0xB0, {0x05}, 1}, {0xB1, {0x1F}, 1}, {0xB2, {0x03}, 1}, {0xB3, {0x01}, 1},
  {0xB4, {0x00}, 1}, {0xB5, {0x00}, 1}, {0xB6, {0x1F}, 1}, {0xB7, {0x00}, 1},
  {0xB8, {0x0F}, 1}, {0xB9, {0x0D}, 1}, {0xBA, {0x0B}, 1}, {0xBB, {0x09}, 1},
  {0xC6, {0x05}, 1}, {0xC7, {0x1F}, 1}, {0xC8, {0x04}, 1}, {0xC9, {0x02}, 1},
  {0xCA, {0x00}, 1}, {0xCB, {0x00}, 1}, {0xCC, {0x1F}, 1}, {0xCD, {0x00}, 1},
  {0xCE, {0x10}, 1}, {0xCF, {0x0E}, 1}, {0xD0, {0x0C}, 1}, {0xD1, {0x0A}, 1},
  {0xFF, {0x30}, 1}, {0xFF, {0x52}, 1}, {0xFF, {0x00}, 1},
  {0x36, {0x0A}, 1}, {0x11, {0x00}, 1},
  {0x00, {200, 0}, LCD_INIT_DELAY_MARKER},
  {0x29, {0x00}, 1},
  {0x00, {100, 0}, LCD_INIT_DELAY_MARKER},
  {0x00, {0x00}, LCD_INIT_END_MARKER},
};

void LCD_Init(void)
{
  LCD_GPIO_Init();
  LCD_Reset();

#if (LCD_CONTROLLER == LCD_CONTROLLER_ST7701)
  LCD_WriteInitTable(ST7701_InitTable);
#elif (LCD_CONTROLLER == LCD_CONTROLLER_NV3052CGRB)
  LCD_WriteInitTable(NV3052CGRB_InitTable);
#endif
}

const char *LCD_GetControllerName(void)
{
#if (LCD_CONTROLLER == LCD_CONTROLLER_ST7701)
  return "ST7701";
#elif (LCD_CONTROLLER == LCD_CONTROLLER_NV3052CGRB)
  return "NV3052CGRB";
#else
  return "UNKNOWN";
#endif
}

static void LCD_GPIO_Init(void)
{
  GPIO_InitTypeDef GPIO_InitStruct = {0};

  LCD_GPIO_CLK_ENABLE();

  GPIO_InitStruct.Mode = GPIO_MODE_OUTPUT_PP;
  GPIO_InitStruct.Pull = GPIO_NOPULL;
  GPIO_InitStruct.Speed = GPIO_SPEED_FREQ_HIGH;

  GPIO_InitStruct.Pin = LCD_SPI_CS_PIN;
  HAL_GPIO_Init(LCD_SPI_CS_GPIO_PORT, &GPIO_InitStruct);

  GPIO_InitStruct.Pin = LCD_SPI_SCL_PIN;
  HAL_GPIO_Init(LCD_SPI_SCL_GPIO_PORT, &GPIO_InitStruct);

  GPIO_InitStruct.Pin = LCD_SPI_SDA_PIN;
  HAL_GPIO_Init(LCD_SPI_SDA_GPIO_PORT, &GPIO_InitStruct);

#if (LCD_USE_RESET_PIN != 0U)
  GPIO_InitStruct.Pin = LCD_RST_PIN;
  HAL_GPIO_Init(LCD_RST_GPIO_PORT, &GPIO_InitStruct);
#endif

  LCD_CS_HIGH();
  LCD_SCL_HIGH();
  LCD_SDA_HIGH();
}

static void LCD_Reset(void)
{
#if (LCD_USE_RESET_PIN != 0U)
  GPIO_PinState inactive_level;

  inactive_level = (LCD_RST_ACTIVE_LEVEL == GPIO_PIN_RESET) ? GPIO_PIN_SET : GPIO_PIN_RESET;
  HAL_GPIO_WritePin(LCD_RST_GPIO_PORT, LCD_RST_PIN, LCD_RST_ACTIVE_LEVEL);
  HAL_Delay(10);
  HAL_GPIO_WritePin(LCD_RST_GPIO_PORT, LCD_RST_PIN, inactive_level);
  HAL_Delay(120);
#else
  HAL_Delay(100);
#endif
}

static void LCD_WriteInitTable(const LCD_InitCmdTypeDef *table)
{
  uint32_t cmd_index = 0U;
  uint8_t data_index;

  while (table[cmd_index].data_bytes != LCD_INIT_END_MARKER)
  {
    if (table[cmd_index].data_bytes == LCD_INIT_DELAY_MARKER)
    {
      HAL_Delay((uint32_t)table[cmd_index].data[0] |
                ((uint32_t)table[cmd_index].data[1] << 8));
    }
    else
    {
      LCD_WriteCommand(table[cmd_index].cmd);

      for (data_index = 0U; data_index < table[cmd_index].data_bytes; data_index++)
      {
        LCD_WriteData(table[cmd_index].data[data_index]);
      }
    }

    cmd_index++;
  }
}

static void LCD_WriteCommand(uint8_t cmd)
{
  LCD_Write9Bits((uint16_t)cmd);
  LCD_DelayUs(100);
}

static void LCD_WriteData(uint8_t data)
{
  LCD_Write9Bits((uint16_t)(0x0100U | data));
  LCD_DelayUs(100);
}

static void LCD_Write9Bits(uint16_t value)
{
  uint8_t i;

  LCD_CS_LOW();

  for (i = 0U; i < 9U; i++)
  {
    LCD_SCL_LOW();

    if ((value & 0x0100U) != 0U)
    {
      LCD_SDA_HIGH();
    }
    else
    {
      LCD_SDA_LOW();
    }

    LCD_DelayUs(5);
    LCD_SCL_HIGH();
    LCD_DelayUs(5);
    value <<= 1;
  }

  LCD_CS_HIGH();
}

static void LCD_DelayUs(uint32_t us)
{
  volatile uint32_t delay;

  delay = (us * (SystemCoreClock / 1000000U)) / 5U;
  if (delay == 0U)
  {
    delay = 1U;
  }

  while (delay-- != 0U)
  {
    __NOP();
  }
}
